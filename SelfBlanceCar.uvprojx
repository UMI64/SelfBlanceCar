# Keil uVision project SelfBlanceCar.uvprojx, settings and files
target Target 1 (6100001::V6.10.1::.\ARMCLANG)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SelfBlanceCar
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=6 wLevel=3
  c include: .\Hard\096OLED;.\Hard\ADC;.\Hard\I2C;.\Hard\MPU6050;.\Hard\PWM;.\Hard\SPI;.\MATH;.\Hard\PCM5102;.\UI
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Main
    ./: Conrtol.cpp main.cpp Conrtol.h Display.cpp Display.h KeyBord.cpp KeyBord.h
  group Hard
    ./Hard/ADC/: ADC.cpp
    ./Hard/096OLED/: 096oled.cpp
    ./Hard/I2C/: I2C.cpp
    ./Hard/MPU6050/: mpu6050.cpp
    ./Hard/PWM/: PWM.cpp
    ./Hard/SPI/: SPI.cpp
    ./Hard/PCM5102/: PCM5102.cpp
    ./: SDCARD.cpp SDCARD.h
  group MATH
    ./MATH/: ahrs.cpp pid.cpp
  group UI
    ./UI/: UI_VIEW.cpp UI_LIST.cpp UI_LIST.hpp UI_VIEW.hpp UI_DEV.hpp UI.hpp UI_CORE_DEV.cpp UI_CORE_TASK_ERAW.cpp
software components: RTOS:Config 10.0.1, RTOS:Core 10.0.1, RTOS:Event Groups 10.0.1, RTOS:Heap 10.0.1, RTOS:Timers 10.0.1, CMSIS:CORE 5.1.2, CMSIS:RTOS2:FreeRTOS 10.0.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SDIO 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0
